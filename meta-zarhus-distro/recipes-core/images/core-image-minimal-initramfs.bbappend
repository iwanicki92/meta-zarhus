INITRAMFS_SCRIPTS = " \
    initramfs-framework-base \
    initramfs-module-udev \
"
