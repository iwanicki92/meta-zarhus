INITRAMFS_SCRIPTS:append = " initramfs-module-encrypt-decrypt"
