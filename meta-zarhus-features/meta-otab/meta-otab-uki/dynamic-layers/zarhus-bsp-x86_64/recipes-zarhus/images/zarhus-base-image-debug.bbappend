# nooelint: oelint.var.multiinclude
require otab-uki.inc
