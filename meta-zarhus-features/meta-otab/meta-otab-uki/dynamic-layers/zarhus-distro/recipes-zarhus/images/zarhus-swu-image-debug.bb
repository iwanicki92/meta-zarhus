OTAB_ROOTFS_IMAGE_NAME = "zarhus-base-image-debug"
require zarhus-swu.inc
