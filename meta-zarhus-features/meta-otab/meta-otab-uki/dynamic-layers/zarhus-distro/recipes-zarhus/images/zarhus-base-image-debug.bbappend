OTAB_ROOTFS_PART_SIZE ?= "3G"

# nooelint: oelint.var.multiinclude
require otab-uki-distro.inc
