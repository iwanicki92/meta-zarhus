FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

OTAB_FILES_WITH_VARIABLES = "${WORKDIR}/boot.cmd.in"

inherit otab_variables_preinstall
